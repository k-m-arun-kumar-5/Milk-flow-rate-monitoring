# Keil uVision project appl_eOS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT87F52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(24000000)
  output: appl_eOS
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c port.h main.h bargraph.c pulse_count.c simple_EOS.c pulse_count.h simple_EOS.h bargraph.h
